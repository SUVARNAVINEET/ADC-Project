# Keil uVision project vinadc.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89CV51RD2 NXP
  cpu: IRAM(0-0xFF) IROM(0x000-0xFFFF) XRAM(0x000-0x2FF)CLOCK(20000000) MODP2
  output: vinadc
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c 8lcdvin.c main.c adc.c
  group New Group
    ./: adc.h delay.h 8lcdvin.h
